# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; CONFIG_USB_DWC2_PORT=FS_PORT; USE_USB_FS; CONFIG_DWC2_GD32; CONFIG_USB_ERROR_USE_SYSTEM; USE_STDPERIPH_DRIVER; USE_HAL_DRIVER; __perf_counter_printf__=rt_kprintf; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../rt-thread/components/libc/posix/io/epoll; applications/lvgl/ui/screens; packages/LVGL-v8.3.11/src/extra/libs/fsdrv; packages/LVGL-v8.3.11/src/extra/widgets/spinner; packages/LVGL-v8.3.11/src/extra/libs/gif; applications/lvgl/ui/images; packages/LVGL-v8.3.11/src/extra/libs; ../../../../rt-thread/components/drivers/spi; packages/LVGL-v8.3.11/src/extra/widgets/calendar; libraries/DAPLink/include; packages/LVGL-v8.3.11/src/draw/nxp/pxp; packages/LVGL-v8.3.11/src/extra/themes/basic; libraries/CherryUSB-0.10.2/common; ../../../../rt-thread/components/libc/compilers/common/extension/fcntl/octal; ../../../../rt-thread/include; ../../../../rt-thread/components/drivers/sdio/sdhci/include; packages/LVGL-v8.3.11/src; packages/micropython-v1.13.0/port/modules; packages/LVGL-v8.3.11/src/extra/themes/default; packages/LVGL-v8.3.11/src/extra/widgets/list; packages/micropython-v1.13.0; packages/LVGL-v8.3.11/src/extra/widgets/tabview; packages/LVGL-v8.3.11/src/extra/widgets; ../../../../rt-thread/components/legacy; ../../../../rt-thread/components/libc/compilers/common/include; packages/uffs-latest; ../../../../rt-thread/components/libc/posix/delay; packages/LVGL-v8.3.11/src/extra/libs/png; packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf; libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Include; board/CubeMX_Config/Inc; packages/micropython-v1.13.0/port/modules/machine; packages/LVGL-v8.3.11/src/extra; packages/LVGL-v8.3.11/src/misc; libraries/HAL_Drivers/CMSIS/Include; packages/LVGL-v8.3.11/src/core; applications/lvgl; packages/LVGL-v8.3.11/src/extra/widgets/win; packages/micropython-v1.13.0/port; libraries/DAPLink/Source/target; packages/LVGL-v8.3.11/src/extra/others/monkey; ../../../../rt-thread/components/utilities/ulog; ../../../../rt-thread/components/drivers/ktime/inc; packages/LVGL-v8.3.11/src/extra/themes; board/ports; packages/LVGL-v8.3.11/src/extra/widgets/imgbtn; packages/LVGL-v8.3.11/src/extra/widgets/colorwheel; ../../../../rt-thread/components/libc/posix/io/termios; packages/mem_sandbox-latest; applications/lvgl/ui; libraries/CherryUSB-0.10.2/core; packages/LVGL-v8.3.11/src/draw/nxp/vglite; ../../../../rt-thread/components/dfs/dfs_v1/include; packages/LVGL-v8.3.11/src/extra/libs/sjpg; packages/LVGL-v8.3.11/src/extra/libs/freetype; ../../../../rt-thread/components/drivers/smp_call; packages/LVGL-v8.3.11/src/extra/widgets/spinbox; packages/LVGL-v8.3.11/src/extra/widgets/led; ../../../../rt-thread/components/net/utest; packages/optparse-latest; libraries/CherryUSB-0.10.2/class/hid; packages/ST7789-master; packages/LVGL-v8.3.11/env_support/rt-thread; ../../../../rt-thread/components/finsh; libraries/HAL_Drivers/drivers; packages/LVGL-v8.3.11/src/extra/widgets/animimg; libraries/CherryRB; ../../../../rt-thread/libcpu/arm/cortex-m4; libraries/DAPLink/Source; packages/LVGL-v8.3.11/src/draw/sw; packages/uffs-latest/src/inc; packages/LVGL-v8.3.11/src/draw; packages/LVGL-v8.3.11/src/extra/others; packages/perf_counter-v2.2.4.1; libraries/HAL_Drivers; ../../../../rt-thread/components/libc/posix/ipc; ../../../../rt-thread/components/dfs/dfs_v1/filesystems/elmfat; packages/LVGL-v8.3.11/src/extra/widgets/tileview; applications/offline_download; packages/LVGL-v8.3.11/src/extra/others/fragment; ../../../../rt-thread/components/libc/posix/io/poll; packages/LVGL-v8.3.11/src/hal; packages/LVGL-v8.3.11/src/extra/libs/qrcode; packages/LVGL-v8.3.11/src/extra/libs/bmp; packages/LVGL-v8.3.11/src/extra/others/snapshot; packages/LVGL-v8.3.11/src/extra/widgets/meter; packages/LVGL-v8.3.11/src/extra/layouts/flex; packages/LVGL-v8.3.11/src/extra/others/ime; ../../../../rt-thread/components/legacy/dfs; packages/LVGL-v8.3.11/src/extra/themes/mono; board; packages/LVGL-v8.3.11/src/extra/widgets/keyboard; packages/LVGL-v8.3.11/src/draw/swm341_dma2d; ../../../../rt-thread/components/drivers/ktime; packages/LVGL-v8.3.11/src/extra/others/msg; packages/LVGL-v8.3.11/src/extra/widgets/chart; ../../../../rt-thread/components/libc/posix/io/stdio; ../../../../rt-thread/components/dfs/dfs_v1/filesystems/romfs; packages/LVGL-v8.3.11/src/extra/widgets/span; packages/LVGL-v8.3.11/src/extra/widgets/menu; packages/FlexibleButton-v1.0.0; libraries/CherryUSB-0.10.2/class/cdc; packages/LVGL-v8.3.11/src/extra/others/imgfont; libraries/uMCN/inc; packages/LVGL-v8.3.11/src/draw/stm32_dma2d; packages/LVGL-v8.3.11/src/extra/widgets/msgbox; packages/LVGL-v8.3.11/src/extra/layouts; packages/LVGL-v8.3.11/src/widgets; .; libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Inc; ../../../../rt-thread/components/libc/posix/io/eventfd; packages/LVGL-v8.3.11/src/draw/arm2d; applications/flmparse; ../../../../rt-thread/components/drivers/include; ../../../../rt-thread/libcpu/arm/common; applications; packages/LVGL-v8.3.11/src/extra/others/gridnav; libraries/DAPLink/Source/hic_hal; libraries/HAL_Drivers/drivers/config; ../../../../rt-thread/components/dfs/dfs_v1/filesystems/devfs; applications/lvgl/ui/fonts; ../../../../rt-thread/components/drivers/phy; libraries/CherryUSB-0.10.2/class/msc; packages/LVGL-v8.3.11/src/extra/libs/rlottie; packages/LVGL-v8.3.11/src/font; packages/LVGL-v8.3.11/src/extra/layouts/grid; packages/LVGL-v8.3.11/src/draw/renesas; packages/LVGL-v8.3.11/src/extra/libs/ffmpeg; libraries/moving-average-library; libraries/DAPLink/Source/interface; ../../../../rt-thread/components/libc/compilers/common/extension; packages/LVGL-v8.3.11/src/draw/sdl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: adc_convert.c power_control.c usb2uart.c runtime_load_indicator.c bsp_dac.c bsp_led.c dap_main.c numeric_tools.c offline_download_thread.c sd_card_thread.c main.c bsp_beep.c dap_loop.c runtime_load_test.c
  group Compiler
    ../../../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../rt-thread/components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    ../../../../rt-thread/components/drivers/block/partitions/: dfs.c efi.c
    ../../../../rt-thread/components/drivers/core/: device.c
    ../../../../rt-thread/components/drivers/cputime/: cputime.c cputime_cortexm.c cputimer.c
    ../../../../rt-thread/components/drivers/hwtimer/: hwtimer.c
    ../../../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../rt-thread/components/drivers/misc/: rt_drv_pwm.c
    ../../../../rt-thread/components/drivers/mtd/: mtd_nand.c
    ../../../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../../../rt-thread/components/drivers/rtc/: dev_rtc.c
    ../../../../rt-thread/components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../../rt-thread/components/drivers/serial/: dev_serial.c
    ../../../../rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: drv_filesystem.c w25n01gv.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_pwm.c drv_sdio.c drv_spi.c drv_tim.c drv_usart.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Filesystem
    ../../../../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../../../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../rt-thread/components/finsh/: shell.c cmd.c msh_parse.c msh_file.c msh.c
  group flex_button
    packages/FlexibleButton-v1.0.0/: flexible_button.c
  group Kernel
    ../../../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../rt-thread/src/klibc/: kstring.c kerrno.c kstdio.c rt_vsscanf.c rt_vsnprintf_tiny.c
  group ktime
    ../../../../rt-thread/components/drivers/ktime/src/: boottime.c cputimer.c hrtimer.c
  group Legacy
    ../../../../rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_tim.c stm32f4xx_hal.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_usart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_rng.c stm32f4xx_hal_dac.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_rtc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cec.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/CherryRB
    libraries/CherryRB/: chry_ringbuffer.c
  group Libraries/CherryUSB
    libraries/CherryUSB-0.10.2/port/dwc2/: usb_dc_dwc2.c
    libraries/CherryUSB-0.10.2/class/cdc/: usbd_cdc.c
    libraries/CherryUSB-0.10.2/core/: usbd_core.c
    libraries/CherryUSB-0.10.2/class/hid/: usbd_hid.c
  group Libraries/DAPLINK
    libraries/DAPLink/Source/: DAP_vendor.c DAP.c SW_DP.c UART.c JTAG_DP.c SWO.c
    libraries/DAPLink/Source/interface/: SWD_flash.c swd_host.c
  group Libraries/fileter
    libraries/moving-average-library/: filter.c
  group LVGL
    packages/LVGL-v8.3.11/src/misc/: lv_log.c lv_area.c lv_lru.c lv_utils.c lv_timer.c lv_txt.c lv_async.c lv_anim_timeline.c lv_templ.c lv_style.c lv_printf.c lv_style_gen.c lv_tlsf.c lv_mem.c lv_math.c lv_fs.c lv_anim.c lv_txt_ap.c lv_gc.c lv_color.c lv_bidi.c lv_ll.c
    packages/LVGL-v8.3.11/src/core/: lv_obj_tree.c lv_indev.c lv_obj_scroll.c lv_obj_pos.c lv_theme.c lv_disp.c lv_obj_class.c lv_refr.c lv_event.c lv_obj_draw.c lv_obj.c lv_obj_style_gen.c lv_obj_style.c lv_group.c lv_indev_scroll.c
    packages/LVGL-v8.3.11/src/font/: lv_font_montserrat_12.c lv_font_montserrat_24.c lv_font_unscii_8.c lv_font_fmt_txt.c lv_font_montserrat_12_subpx.c lv_font_montserrat_40.c lv_font_montserrat_16.c lv_font_montserrat_44.c lv_font_montserrat_48.c lv_font_loader.c lv_font_montserrat_42.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_46.c lv_font_montserrat_36.c lv_font.c lv_font_montserrat_38.c lv_font_unscii_16.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_28.c lv_font_montserrat_8.c lv_font_montserrat_22.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_26.c lv_font_montserrat_10.c lv_font_montserrat_20.c lv_font_montserrat_18.c lv_font_montserrat_14.c lv_font_simsun_16_cjk.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw_mask.c lv_draw_label.c lv_draw.c lv_img_buf.c lv_draw_line.c lv_draw_triangle.c lv_img_decoder.c lv_draw_arc.c lv_draw_rect.c lv_img_cache.c lv_draw_img.c lv_draw_layer.c lv_draw_transform.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_line.c lv_draw_sw_dither.c lv_draw_sw_layer.c lv_draw_sw_blend.c lv_draw_sw_img.c lv_draw_sw_arc.c lv_draw_sw_gradient.c lv_draw_sw.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw_letter.c lv_draw_sw_polygon.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/LVGL-v8.3.11/src/widgets/: lv_bar.c lv_table.c lv_arc.c lv_line.c lv_checkbox.c lv_label.c lv_switch.c lv_roller.c lv_canvas.c lv_btn.c lv_objx_templ.c lv_textarea.c lv_btnmatrix.c lv_img.c lv_slider.c lv_dropdown.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl_label.c lv_draw_sdl_polygon.c lv_draw_sdl_arc.c lv_draw_sdl_composite.c lv_draw_sdl_line.c lv_draw_sdl_layer.c lv_draw_sdl_mask.c lv_draw_sdl_stack_blur.c lv_draw_sdl_bg.c lv_draw_sdl.c lv_draw_sdl_rect.c lv_draw_sdl_img.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite_blend.c lv_vglite_utils.c lv_draw_vglite_arc.c lv_draw_vglite.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_draw_vglite_line.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_tick.c lv_hal_indev.c lv_hal_disp.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_posix.c lv_fs_littlefs.c lv_fs_fatfs.c lv_fs_win32.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group mem_sandbox
    packages/mem_sandbox-latest/: mem_sandbox.c
  group MicroPython
    packages/micropython-v1.13.0/py/: builtinhelp.c malloc.c objfloat.c objset.c stackctrl.c modsys.c objenumerate.c objobject.c objslice.c emitnxtensawin.c modarray.c modcmath.c objtuple.c formatfloat.c gc.c modstruct.c objcomplex.c objfun.c objnone.c asmx86.c objgenerator.c objstrunicode.c scope.c unicode.c emitinlinethumb.c argcheck.c objstringio.c objzip.c objint.c builtinimport.c scheduler.c smallint.c compile.c emitnx64.c modbuiltins.c modgc.c repl.c showbc.c emitnxtensa.c mpstate.c objfilter.c ringbuf.c vm.c modio.c objexcept.c objgetitemiter.c objproperty.c bc.c moduerrno.c objint_mpz.c opmethods.c asmthumb.c lexer.c nlrxtensa.c objint_longlong.c qstr.c reader.c mpprint.c obj.c objdeque.c objreversed.c persistentcode.c binary.c objbool.c objnamedtuple.c sequence.c emitbc.c emitnarm.c nlrx86.c objtype.c modcollections.c modmicropython.c objmap.c parse.c runtime_utils.c asmxtensa.c nlrthumb.c objattrtuple.c objpolyiter.c runtime.c nativeglue.c objcell.c objdict.c objsingleton.c asmarm.c emitinlinextensa.c emitnative.c vstr.c asmbase.c emitcommon.c emitnthumb.c objboundmeth.c objlist.c emitglue.c mpz.c nlr.c objmodule.c parsenum.c stream.c nlrsetjmp.c nlrx64.c objrange.c profile.c asmx64.c map.c objclosure.c pystack.c builtinevex.c nlrpowerpc.c objstr.c pairheap.c parsenumbase.c emitnx86.c frozenmod.c modmath.c modthread.c objarray.c warning.c
    packages/micropython-v1.13.0/extmod/: modurandom.c modussl_mbedtls.c modujson.c machine_i2c.c vfs_reader.c moducryptolib.c vfs_fat_diskio.c vfs_fat.c modure.c modframebuf.c moductypes.c vfs.c modonewire.c vfs_posix_file.c utime_mphal.c moduwebsocket.c machine_pulse.c vfs_posix.c machine_pinbase.c moduhashlib.c moduzlib.c machine_mem.c machine_spi.c modwebsocket.c machine_signal.c moduselect.c modussl_axtls.c modubinascii.c moduheapq.c virtpin.c modwebrepl.c uos_dupterm.c modbtree.c modutimeq.c vfs_fat_file.c
    packages/micropython-v1.13.0/port/modules/: modfile.c modpyb.c moduos.c modffi.c modusocket.c modnetwork.c modnetwork_wlan.c moduos_file.c modutime.c modrtthread.c modutils.c
    packages/micropython-v1.13.0/lib/utils/: pyexec.c mpirq.c stdout_helpers.c printf.c interrupt_char.c sys_stdio_mphal.c
    packages/micropython-v1.13.0/port/: gccollect.c mpy_main.c mphalport.c mpgetcharport.c mpputsnport.c frozen_mpy.c mpthreadport.c
    packages/micropython-v1.13.0/port/modules/machine/: machine_uart.c machine_wdt.c modmachine.c machine_adc.c machine_rtc.c machine_pwm.c machine_hw_i2c.c machine_timer.c machine_pin.c machine_lcd.c machine_hw_spi.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
    packages/micropython-v1.13.0/drivers/bus/: softqspi.c softspi.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
    packages/micropython-v1.13.0/port/native/: native_module.c easyflash_module.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
  group offline_download
    applications/flmparse/: flmparse.c
    applications/offline_download/: swd_download_file.c
  group optparse
    packages/optparse-latest/: optparse.c
  group perf_counter
    packages/perf_counter-v2.2.4.1/os/: perf_os_patch_rt_thread.c
    packages/perf_counter-v2.2.4.1/: perf_counter.c
  group POSIX
    ../../../../rt-thread/components/libc/posix/delay/: delay.c
    ../../../../rt-thread/components/libc/posix/io/poll/: poll.c
    ../../../../rt-thread/components/libc/posix/io/stdio/: stdio.c
    ../../../../rt-thread/components/libc/posix/io/termios/: termios.c
  group st7789
    packages/ST7789-master/: lcd_st7789.c
  group uffs
    packages/uffs-latest/src/uffs/: uffs_pool.c uffs_find.c uffs_debug.c uffs_fd.c uffs_badblock.c uffs_init.c uffs_mtb.c uffs_public.c uffs_blockinfo.c uffs_fs.c uffs_tree.c uffs_crc.c uffs_mem.c uffs_buf.c uffs_utils.c uffs_device.c uffs_version.c uffs_flash.c uffs_ecc.c
    packages/uffs-latest/: uffs_rtthread.c uffs_nandif.c dfs_uffs.c
  group UI
    applications/lvgl/ui/fonts/: ui_font_PuHuiTi.c ui_font_PuHuiTi16GB2312.c ui_font_PuHuiTi25.c ui_font_PuHuiTi30.c ui_font_jetbrainsMonoMedium16.c ui_font_jetbrainsMonoMedium20.c ui_font_jetbrainsMonoMedium25.c
    applications/lvgl/ui/: lv_file_explorer.c lvgl_data_update.c screens.c ui.c ui_events.c ui_helpers.c
    applications/lvgl/ui/screens/: ui_About.c ui_DACoutput.c ui_DAPLINK.c ui_FileExplorer.c ui_Menu.c ui_OfflineDownload.c ui_PWMoutput.c ui_UartMonitor.c ui_VoltAmmeter.c
  group uMCN
    libraries/uMCN/src/: uMCN.c cmd_mcn.c
  group Utilities
    ../../../../rt-thread/components/utilities/ulog/: ulog.c
    ../../../../rt-thread/components/utilities/ulog/backend/: console_be.c
  group vi
    packages/vi-latest/editors/: vi.c vi_utils.c
