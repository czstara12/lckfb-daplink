# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __RTTHREAD__, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER, __perf_counter_printf__=rt_kprintf, CONFIG_DWC2_GD32, RT_USING_ARMLIBC, RT_USING_LIBC, LFS_CONFIG=lfs_config.h, __STDC_LIMIT_MACROS, CONFIG_USB_ERROR_USE_SYSTEM, CONFIG_USB_DWC2_PORT=FS_PORT, USE_USB_FS, STM32F407xx
  c include: libraries\DAPLink\include;libraries\CherryUSB-0.10.2\core;packages\littlefs-v2.11.2;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;..\..\..\rt-thread\components\drivers\include;libraries\moving-average-library;applications;..\..\..\rt-thread\include;libraries\CherryRB;packages\optparse-latest;libraries\CherryUSB-0.10.2\common;.;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;libraries\DAPLink\Source\target;libraries\DAPLink\Source;packages\LVGL-v8.3.11\src\draw;libraries\DAPLink\Source\interface;packages\LVGL-v8.3.11\src\extra\others\imgfont;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\micropython-v1.13.0;applications\lvgl\ui\fonts;libraries\HAL_Drivers\drivers\drv_flash;..\..\..\rt-thread\components\fal\inc;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\micropython-v1.13.0\port\modules;applications\lvgl\ui;packages\LVGL-v8.3.11\src\draw\renesas;..\..\..\rt-thread\components\libc\posix\io\stdio;..\..\..\rt-thread\components\libc\posix\io\termios;..\..\..\rt-thread\libcpu\arm\common;packages\LVGL-v8.3.11\src\extra\themes\basic;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\src\misc;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\LVGL-v8.3.11\src\extra\libs\freetype;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\extra\widgets\list;board\ports;..\..\..\rt-thread\components\drivers\ktime;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\draw\sw;..\..\..\rt-thread\libcpu\arm\cortex-m4;packages\LVGL-v8.3.11\src\core;packages\LVGL-v8.3.11\src\extra\widgets\chart;..\..\..\rt-thread\components\finsh;libraries\HAL_Drivers\drivers;..\..\..\rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\LVGL-v8.3.11\src;packages\LVGL-v8.3.11\src\draw\sdl;packages\LVGL-v8.3.11\src\draw\nxp\vglite;applications\lvgl\ui\images;packages\LVGL-v8.3.11\src\extra\layouts;libraries\HAL_Drivers;packages\micropython-v1.13.0\port\modules\machine;..\..\..\rt-thread\components\drivers\ktime\inc;..\..\..\rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\LVGL-v8.3.11\src\draw\nxp\pxp;packages\LVGL-v8.3.11\src\extra\libs\png;applications\lvgl\ui\screens;packages\LVGL-v8.3.11\src\widgets;..\..\..\rt-thread\components\dfs\dfs_v1\include;libraries\CherryUSB-0.10.2\class\hid;board;..\..\..\rt-thread\components\dfs\dfs_v1\filesystems\romfs;packages\LVGL-v8.3.11\src\extra\themes\default;packages\LVGL-v8.3.11\src\extra\widgets\tileview;packages\LVGL-v8.3.11\src\extra\others\monkey;..\..\..\rt-thread\components\legacy;packages\LVGL-v8.3.11\src\extra\widgets\led;..\..\..\rt-thread\components\drivers\phy;packages\micropython-v1.13.0\port;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\meter;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\hal;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\ST7789-master;libraries\CherryUSB-0.10.2\class\msc;packages\LVGL-v8.3.11\src\extra\widgets\animimg;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\qrcode;..\..\..\rt-thread\components\drivers\sdio\sdhci\include;libraries\CherryUSB-0.10.2\class\cdc;packages\LVGL-v8.3.11\src\extra\widgets\span;packages\perf_counter-v2.2.4.1;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;..\..\..\rt-thread\components\utilities\ulog;packages\LVGL-v8.3.11\src\extra\themes\mono;applications\offline_download;..\..\..\rt-thread\components\libc\compilers\common\extension;..\..\..\rt-thread\components\drivers\include;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\rt-thread\components\libc\posix\delay;..\..\..\rt-thread\components\drivers\spi\sfud\inc;packages\LVGL-v8.3.11\src\extra\libs\sjpg;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;..\..\..\rt-thread\components\libc\posix\io\epoll;packages\LVGL-v8.3.11\src\extra\widgets\tabview;libraries\HAL_Drivers\drivers\config;..\..\..\rt-thread\components\libc\posix\ipc;applications\lvgl;board\CubeMX_Config\Inc;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\src\extra\libs\rlottie;..\..\..\rt-thread\components\libc\posix\io\eventfd;board\ports\fal;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;libraries\HAL_Drivers\CMSIS\Include;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\FlexibleButton-v1.0.0;packages\LVGL-v8.3.11\src\extra\libs;packages\LVGL-v8.3.11\src\extra\libs\gif;packages\LVGL-v8.3.11\src\extra\others\msg;packages\LVGL-v8.3.11\src\draw\arm2d;libraries\uMCN\inc;packages\LVGL-v8.3.11\src\extra\layouts\flex;..\..\..\rt-thread\components\libc\posix\io\poll;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\src\extra\widgets\win;packages\LVGL-v8.3.11\src\font;..\..\..\rt-thread\components\drivers\include;libraries\DAPLink\Source\hic_hal;packages\mem_sandbox-latest;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;..\..\..\rt-thread\components\libc\compilers\common\include;..\..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.11\src\extra\widgets;..\..\..\rt-thread\components\legacy\dfs;..\..\..\rt-thread\components\drivers\spi;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;applications\flmparse;packages\LVGL-v8.3.11\src\extra\libs\bmp;..\..\..\rt-thread\components\net\utest;..\..\..\rt-thread\components\drivers\smp_call;packages\LVGL-v8.3.11\src\extra\others;..\..\..\rt-thread\components\drivers\include
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: adc_convert.c main.c numeric_tools.c bsp_beep.c sd_card_thread.c bsp_led.c runtime_load_indicator.c bsp_dac.c runtime_load_test.c offline_download_thread.c usb2uart.c power_control.c dap_main.c dap_loop.c
  group Compiler
    ../../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    ../../../rt-thread/components/drivers/block/partitions/: dfs.c efi.c
    ../../../rt-thread/components/drivers/core/: device.c
    ../../../rt-thread/components/drivers/cputime/: cputime.c cputime_cortexm.c cputimer.c
    ../../../rt-thread/components/drivers/hwtimer/: hwtimer.c
    ../../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rt-thread/components/drivers/misc/: dac.c rt_drv_pwm.c
    ../../../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../../rt-thread/components/drivers/rtc/: dev_rtc.c
    ../../../rt-thread/components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../rt-thread/components/drivers/serial/: dev_serial.c
    ../../../rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: drv_filesystem.c spi_flash_init.c
    board/ports/fal/: fal_spi_flash_sfud_port.c
    libraries/HAL_Drivers/drivers/: drv_dac.c drv_gpio.c drv_pwm.c drv_sdio.c drv_spi.c drv_tim.c drv_usart.c
    libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_f4.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Fal
    ../../../rt-thread/components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../../../rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../rt-thread/components/finsh/: msh.c msh_file.c cmd.c shell.c msh_parse.c
  group flex_button
    packages/FlexibleButton-v1.0.0/: flexible_button.c
  group Kernel
    ../../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../rt-thread/src/klibc/: rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c kerrno.c kstring.c
  group ktime
    ../../../rt-thread/components/drivers/ktime/src/: boottime.c cputimer.c hrtimer.c
  group Legacy
    ../../../rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_adc.c stm32f4xx_hal.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rng.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_dac.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cec.c stm32f4xx_hal_sd.c stm32f4xx_hal_usart.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_pwr.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/CherryRB
    libraries/CherryRB/: chry_ringbuffer.c
  group Libraries/CherryUSB
    libraries/CherryUSB-0.10.2/class/cdc/: usbd_cdc.c
    libraries/CherryUSB-0.10.2/core/: usbd_core.c
    libraries/CherryUSB-0.10.2/port/dwc2/: usb_dc_dwc2.c
    libraries/CherryUSB-0.10.2/class/hid/: usbd_hid.c
  group Libraries/DAPLINK
    libraries/DAPLink/Source/: UART.c SW_DP.c DAP_vendor.c JTAG_DP.c SWO.c DAP.c
    libraries/DAPLink/Source/interface/: swd_host.c SWD_flash.c
  group Libraries/fileter
    libraries/moving-average-library/: filter.c
  group littlefs
    packages/littlefs-v2.11.2/: lfs_util.c lfs.c dfs_lfs.c lfs_crc.c
  group LVGL
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_line.c lv_draw_sdl_texture_cache.c lv_draw_sdl_bg.c lv_draw_sdl_img.c lv_draw_sdl_mask.c lv_draw_sdl_composite.c lv_draw_sdl_polygon.c lv_draw_sdl_layer.c lv_draw_sdl_utils.c lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_label.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/misc/: lv_area.c lv_txt_ap.c lv_anim.c lv_printf.c lv_timer.c lv_style.c lv_utils.c lv_async.c lv_txt.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_color.c lv_mem.c lv_math.c lv_templ.c lv_bidi.c lv_tlsf.c lv_style_gen.c lv_anim_timeline.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw_img.c lv_img_buf.c lv_draw_triangle.c lv_img_decoder.c lv_draw_arc.c lv_draw_transform.c lv_draw.c lv_img_cache.c lv_draw_rect.c lv_draw_mask.c lv_draw_line.c lv_draw_layer.c lv_draw_label.c
    packages/LVGL-v8.3.11/src/font/: lv_font_montserrat_10.c lv_font_montserrat_34.c lv_font_montserrat_8.c lv_font_montserrat_16.c lv_font_montserrat_40.c lv_font_simsun_16_cjk.c lv_font_montserrat_36.c lv_font_montserrat_24.c lv_font_montserrat_38.c lv_font_unscii_8.c lv_font_montserrat_42.c lv_font_montserrat_28.c lv_font_montserrat_44.c lv_font_dejavu_16_persian_hebrew.c lv_font_unscii_16.c lv_font_montserrat_46.c lv_font_montserrat_22.c lv_font_loader.c lv_font_montserrat_12_subpx.c lv_font_montserrat_20.c lv_font_montserrat_14.c lv_font_montserrat_12.c lv_font_montserrat_32.c lv_font_fmt_txt.c lv_font_montserrat_28_compressed.c lv_font_montserrat_48.c lv_font_montserrat_26.c lv_font_montserrat_18.c lv_font_montserrat_30.c lv_font.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_gpu_nxp_pxp_osa.c lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.11/src/core/: lv_refr.c lv_obj_class.c lv_obj_pos.c lv_obj_draw.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_disp.c lv_obj_scroll.c lv_event.c lv_obj_style.c lv_obj_style_gen.c lv_group.c lv_theme.c lv_obj_tree.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_vglite_buf.c lv_draw_vglite_blend.c lv_draw_vglite_arc.c lv_draw_vglite.c lv_vglite_utils.c lv_draw_vglite_rect.c lv_draw_vglite_line.c
    packages/LVGL-v8.3.11/src/widgets/: lv_checkbox.c lv_line.c lv_canvas.c lv_objx_templ.c lv_arc.c lv_btn.c lv_dropdown.c lv_img.c lv_slider.c lv_bar.c lv_roller.c lv_btnmatrix.c lv_switch.c lv_label.c lv_table.c lv_textarea.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_posix.c lv_fs_win32.c lv_fs_fatfs.c lv_fs_littlefs.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_blend.c lv_draw_sw_gradient.c lv_draw_sw_layer.c lv_draw_sw_arc.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_dither.c lv_draw_sw.c lv_draw_sw_rect.c lv_draw_sw_img.c lv_draw_sw_transform.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group mem_sandbox
    packages/mem_sandbox-latest/: mem_sandbox.c
  group MicroPython
    packages/micropython-v1.13.0/py/: emitnxtensawin.c modcmath.c nlrsetjmp.c objboundmeth.c emitinlinethumb.c objdeque.c scope.c vm.c showbc.c objenumerate.c formatfloat.c objmodule.c objreversed.c stream.c opmethods.c objarray.c objnone.c objstr.c asmx86.c objcell.c parsenumbase.c runtime.c modmicropython.c objtuple.c builtinimport.c frozenmod.c objobject.c lexer.c asmxtensa.c profile.c binary.c objint.c asmarm.c nativeglue.c smallint.c objcomplex.c vstr.c modio.c nlrx64.c emitinlinextensa.c objgenerator.c qstr.c objint_longlong.c objstringio.c emitnative.c gc.c objpolyiter.c nlrxtensa.c emitnarm.c objclosure.c modstruct.c mpprint.c builtinhelp.c repl.c mpstate.c bc.c objint_mpz.c emitnx64.c warning.c map.c objsingleton.c argcheck.c scheduler.c asmbase.c objlist.c modthread.c moduerrno.c malloc.c objset.c nlr.c compile.c objdict.c emitnx86.c pairheap.c nlrthumb.c parse.c builtinevex.c objexcept.c stackctrl.c modbuiltins.c asmx64.c objproperty.c emitcommon.c emitnthumb.c objmap.c modarray.c objstrunicode.c asmthumb.c objattrtuple.c pystack.c objfilter.c modmath.c mpz.c parsenum.c runtime_utils.c objfloat.c unicode.c objslice.c nlrx86.c sequence.c emitnxtensa.c objrange.c objbool.c emitbc.c objfun.c reader.c modcollections.c objzip.c ringbuf.c objnamedtuple.c modsys.c nlrpowerpc.c persistentcode.c emitglue.c objgetitemiter.c modgc.c objtype.c obj.c
    packages/micropython-v1.13.0/extmod/: machine_pinbase.c moduheapq.c utime_mphal.c modbtree.c machine_pulse.c modussl_mbedtls.c modframebuf.c uos_dupterm.c machine_signal.c vfs_posix_file.c moducryptolib.c modussl_axtls.c modubinascii.c machine_spi.c modonewire.c modutimeq.c vfs_reader.c virtpin.c moduzlib.c modujson.c vfs_fat_diskio.c moduhashlib.c vfs_posix.c modurandom.c vfs_fat.c moduselect.c modwebsocket.c modure.c moduwebsocket.c vfs_fat_file.c machine_i2c.c moductypes.c vfs.c machine_mem.c modwebrepl.c
    packages/micropython-v1.13.0/port/modules/: modutime.c modnetwork_wlan.c modffi.c modrtthread.c moduos_file.c modnetwork.c modpyb.c modfile.c modutils.c moduos.c modusocket.c
    packages/micropython-v1.13.0/port/native/: native_module.c easyflash_module.c
    packages/micropython-v1.13.0/port/modules/machine/: machine_pwm.c machine_wdt.c machine_hw_spi.c machine_hw_i2c.c machine_rtc.c modmachine.c machine_lcd.c machine_adc.c machine_timer.c machine_uart.c machine_pin.c
    packages/micropython-v1.13.0/lib/timeutils/: timeutils.c
    packages/micropython-v1.13.0/port/: mpy_main.c mpthreadport.c mpputsnport.c gccollect.c mpgetcharport.c frozen_mpy.c mphalport.c
    packages/micropython-v1.13.0/lib/utils/: printf.c pyexec.c stdout_helpers.c sys_stdio_mphal.c interrupt_char.c mpirq.c
    packages/micropython-v1.13.0/drivers/bus/: softspi.c softqspi.c
    packages/micropython-v1.13.0/lib/mp-readline/: readline.c
    packages/micropython-v1.13.0/port/modules/user/: moduserfunc.c
    packages/micropython-v1.13.0/lib/netutils/: netutils.c
  group offline_download
    applications/flmparse/: flmparse.c
    applications/offline_download/: swd_download_file.c
  group optparse
    packages/optparse-latest/: optparse.c
  group perf_counter
    packages/perf_counter-v2.2.4.1/: perf_counter.c
    packages/perf_counter-v2.2.4.1/os/: perf_os_patch_rt_thread.c
  group POSIX
    ../../../rt-thread/components/libc/posix/delay/: delay.c
    ../../../rt-thread/components/libc/posix/io/poll/: poll.c
    ../../../rt-thread/components/libc/posix/io/stdio/: stdio.c
    ../../../rt-thread/components/libc/posix/io/termios/: termios.c
  group st7789
    packages/ST7789-master/: lcd_st7789.c
  group UI
    applications/lvgl/ui/fonts/: ui_font_PuHuiTi.c ui_font_PuHuiTi16GB2312.c ui_font_PuHuiTi25.c ui_font_PuHuiTi30.c ui_font_jetbrainsMonoMedium16.c ui_font_jetbrainsMonoMedium20.c ui_font_jetbrainsMonoMedium25.c
    applications/lvgl/ui/: lv_file_explorer.c lvgl_data_update.c screens.c ui.c ui_events.c ui_helpers.c
    applications/lvgl/ui/screens/: ui_About.c ui_DACoutput.c ui_DAPLINK.c ui_FileExplorer.c ui_Menu.c ui_OfflineDownload.c ui_PWMoutput.c ui_UartMonitor.c ui_VoltAmmeter.c
  group uMCN
    libraries/uMCN/src/: uMCN.c cmd_mcn.c
  group Utilities
    ../../../rt-thread/components/utilities/ulog/: ulog.c
    ../../../rt-thread/components/utilities/ulog/backend/: console_be.c
  group vi
    packages/vi-latest/editors/: vi_utils.c vi.c
