# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ac5)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__, __TARGET_FPU_VFP, USE_STDPERIPH_DRIVER, GD32F407, __CLK_TCK=RT_TICK_PER_SECOND, USE_USB_FS,CONFIG_DWC2_GD32, CONFIG_USB_DWC2_PORT=FS_PORT, __STDC_LIMIT_MACROS, LCKFB_SKYSTART_GD32F407V, CONFIG_USB_ERROR_USE_SYSTEM
  c misc: --no-multibyte-chars
  c include: packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\LVGL-v8.3.11\src\extra\layouts;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\devfs;libraries\CherryUSB-0.10.2\class\hid;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\extra\themes\basic;libraries\DAPLink\Source;packages\LVGL-v8.3.11\src\extra\libs\freetype;packages\LVGL-v8.3.11\src\extra\others\msg;packages\LVGL-v8.3.11\src\extra\libs\png;rt-thread\components\drivers\include;applications\lvgl;rt-thread\components\libc\posix\io\eventfd;libraries\DAPLink\Source\target;packages\LVGL-v8.3.11\src\extra\libs\bmp;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;packages\FlexibleButton-v1.0.0;packages\LVGL-v8.3.11\src\draw\renesas;.;packages\LVGL-v8.3.11\src\extra\widgets\list;applications\lvgl\ui\screens;rt-thread\components\libc\posix\ipc;libraries\CherryUSB-0.10.2\core;libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;libraries\gd32_drivers;packages\LVGL-v8.3.11\src\extra\others\monkey;applications\offline_download;libraries\CherryUSB-0.10.2\common;libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;packages\LVGL-v8.3.11\src\extra\themes\mono;rt-thread\components\dfs\dfs_v1\include;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;packages\LVGL-v8.3.11\src\font;packages\LVGL-v8.3.11\src\draw\arm2d;rt-thread\components\drivers\include;applications\lvgl\ui\fonts;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\LVGL-v8.3.11\src\extra\themes\default;libraries\GD32F4xx_Firmware_Library\CMSIS;packages\LVGL-v8.3.11\src\draw\sw;libraries\DAPLink\Source\hic_hal;packages\LVGL-v8.3.11\src\draw\sdl;libraries\DAPLink\include;packages\optparse-v1.0.0;packages\LVGL-v8.3.11\src\extra\libs;libraries\moving-average-library;packages\LVGL-v8.3.11\src\misc;rt-thread\components\legacy;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\src\extra\widgets\animimg;rt-thread\components\drivers\ktime\inc;rt-thread\components\libc\posix\io\epoll;packages\uMCN-latest\inc;packages\ST7789-master;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;packages\LVGL-v8.3.11\src\extra\libs\gif;packages\LVGL-v8.3.11\src\extra\libs\sjpg;libraries\DAPLink\Source\interface;packages\LVGL-v8.3.11\src\draw;rt-thread\include;applications;rt-thread\components\legacy\dfs;applications\lvgl\ui;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;packages\LVGL-v8.3.11\src\extra\widgets\led;libraries\CherryRB;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\src\draw\nxp\pxp;rt-thread\components\finsh;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\LVGL-v8.3.11\src\core;packages\LVGL-v8.3.11\src\extra\widgets\calendar;rt-thread\components\utilities\ulog;rt-thread\components\libc\compilers\common\extension;packages\LVGL-v8.3.11\src\draw\nxp\vglite;packages\LVGL-v8.3.11\src;applications\lvgl\ui\images;packages\LVGL-v8.3.11\src\extra\widgets;packages\LVGL-v8.3.11\src\extra\libs\rlottie;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\LVGL-v8.3.11\src\extra\widgets\meter;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;packages\LVGL-v8.3.11\src\extra\widgets\win;rt-thread\components\libc\compilers\common\extension\fcntl\octal;applications\flmparse;rt-thread\components\libc\posix\delay;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\extra\widgets\tileview;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\src\extra\widgets\chart;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;board;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\extra\widgets\span;libraries\CherryUSB-0.10.2\class\cdc;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\extra\layouts\flex;packages\LVGL-v8.3.11\src\widgets;libraries\CherryUSB-0.10.2\class\msc;packages\LVGL-v8.3.11\src\extra\others\imgfont;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\ktime;rt-thread\components\dfs\dfs_v1\filesystems\romfs;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\LVGL-v8.3.11\src\extra\widgets\tabview
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: numeric_tools.c adc_convert.c bsp_beep.c offline_download_thread.c bsp_dac.c dap_main.c sd_card_thread.c dap_loop.c main.c flexible_button_thread.c bsp_led.c usb2uart.c power_control.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: board.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    libraries/gd32_drivers/: drv_gpio.c drv_pwm.c drv_sdio.c drv_spi.c drv_usart.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group flex_button
    packages/FlexibleButton-v1.0.0/: flexible_button.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group ktime
    rt-thread/components/drivers/ktime/src/: cputimer.c boottime.c hrtimer.c
  group Legacy
    rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_dac.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_syscfg.c gd32f4xx_sdio.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_spi.c gd32f4xx_adc.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Libraries/CherryRB
    libraries/CherryRB/: chry_ringbuffer.c
  group Libraries/CherryUSB
    libraries/CherryUSB-0.10.2/class/hid/: usbd_hid.c
    libraries/CherryUSB-0.10.2/port/dwc2/: usb_dc_dwc2.c
    libraries/CherryUSB-0.10.2/core/: usbd_core.c
    libraries/CherryUSB-0.10.2/class/cdc/: usbd_cdc.c
  group Libraries/DAPLINK
    libraries/DAPLink/Source/: DAP_vendor.c SW_DP.c DAP.c SWO.c UART.c JTAG_DP.c
    libraries/DAPLink/Source/interface/: swd_host.c SWD_flash.c
  group Libraries/fileter
    libraries/moving-average-library/: filter.c
  group LVGL
    packages/LVGL-v8.3.11/src/core/: lv_obj_style_gen.c lv_obj_tree.c lv_event.c lv_refr.c lv_group.c lv_theme.c lv_indev.c lv_disp.c lv_indev_scroll.c lv_obj.c lv_obj_draw.c lv_obj_class.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c
    packages/LVGL-v8.3.11/src/widgets/: lv_img.c lv_roller.c lv_btn.c lv_dropdown.c lv_bar.c lv_arc.c lv_line.c lv_objx_templ.c lv_btnmatrix.c lv_slider.c lv_table.c lv_label.c lv_checkbox.c lv_textarea.c lv_switch.c lv_canvas.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw_arc.c lv_draw.c lv_draw_rect.c lv_draw_mask.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c lv_draw_line.c lv_img_buf.c lv_draw_img.c lv_draw_layer.c lv_draw_label.c lv_draw_transform.c
    packages/LVGL-v8.3.11/src/font/: lv_font_fmt_txt.c lv_font_dejavu_16_persian_hebrew.c lv_font_simsun_16_cjk.c lv_font_montserrat_22.c lv_font_montserrat_34.c lv_font_montserrat_28_compressed.c lv_font_unscii_8.c lv_font_montserrat_26.c lv_font_montserrat_36.c lv_font_montserrat_18.c lv_font_montserrat_10.c lv_font_montserrat_8.c lv_font_unscii_16.c lv_font_montserrat_24.c lv_font_montserrat_46.c lv_font_montserrat_44.c lv_font_montserrat_30.c lv_font_montserrat_48.c lv_font_loader.c lv_font_montserrat_42.c lv_font_montserrat_12_subpx.c lv_font_montserrat_32.c lv_font.c lv_font_montserrat_12.c lv_font_montserrat_40.c lv_font_montserrat_38.c lv_font_montserrat_16.c lv_font_montserrat_28.c lv_font_montserrat_20.c lv_font_montserrat_14.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_posix.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.3.11/src/misc/: lv_color.c lv_log.c lv_tlsf.c lv_area.c lv_math.c lv_mem.c lv_lru.c lv_txt_ap.c lv_timer.c lv_style.c lv_fs.c lv_utils.c lv_anim_timeline.c lv_ll.c lv_printf.c lv_anim.c lv_gc.c lv_async.c lv_txt.c lv_style_gen.c lv_templ.c lv_bidi.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c lv_draw_pxp_blend.c lv_draw_pxp.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_rect.c lv_draw_sw_line.c lv_draw_sw_transform.c lv_draw_sw_arc.c lv_draw_sw_gradient.c lv_draw_sw_dither.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_layer.c lv_draw_sw_polygon.c lv_draw_sw.c lv_draw_sw_blend.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_rect.c lv_draw_sdl_composite.c lv_draw_sdl_polygon.c lv_draw_sdl_texture_cache.c lv_draw_sdl_img.c lv_draw_sdl_stack_blur.c lv_draw_sdl_label.c lv_draw_sdl_utils.c lv_draw_sdl_bg.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl.c lv_draw_sdl_arc.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_disp.c lv_hal_tick.c lv_hal_indev.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_vglite_utils.c lv_draw_vglite.c lv_draw_vglite_line.c lv_draw_vglite_blend.c lv_vglite_buf.c lv_draw_vglite_rect.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group offline_download
    applications/flmparse/: flmparse.c
    applications/offline_download/: swd_download_file.c
  group optparse
    packages/optparse-v1.0.0/: optparse.c
  group POSIX
    rt-thread/components/libc/posix/delay/: delay.c
  group st7789
    packages/ST7789-master/: lcd_st7789.c
  group UI
    applications/lvgl/ui/fonts/: ui_font_PuHuiTi.c ui_font_PuHuiTi25.c ui_font_PuHuiTi30.c ui_font_PuHuiTi35.c ui_font_PuhuiTi20.c ui_font_jetbrainsMonoMedium.c ui_font_jetbrainsMonoMedium16.c ui_font_jetbrainsMonoMedium20.c ui_font_jetbrainsMonoMedium25.c
    applications/lvgl/ui/images/: ui_img_743788411.c ui_img_logo_png.c
    applications/lvgl/ui/: lv_file_explorer.c lvgl_data_update.c screens.c ui.c ui_events.c ui_helpers.c
    applications/lvgl/ui/screens/: ui_About.c ui_DACoutput.c ui_DAPLINK.c ui_FileExplorer.c ui_INIT.c ui_Menu.c ui_OfflineDownload.c ui_PWMoutput.c ui_UartMonitor.c ui_VoltAmmeter.c
  group uMCN
    packages/uMCN-latest/src/: cmd_mcn.c uMCN.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
software components: CMSIS:CORE 5.6.0
